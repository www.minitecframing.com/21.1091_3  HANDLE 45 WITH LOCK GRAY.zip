# Autodesk Inventor assembly: 1000-B50_ASM
## iProperties
Created: 2007-03
Part Number: 1000-B50_ASM
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
